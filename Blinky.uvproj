# Keil uVision project Blinky.uvproj, settings and files
target MCBSTM32C (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c define: STM32F10X_CL
  c include: ..\STM32F10x_StdPeriph_Lib_V3.5.0\QQheaders;..\..\dex
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup Code
    ./: startup_stm32f10x_cl.s
  group Flash Options
    ./: STM32F10xOPT.s
  group System Code
    ./: system_stm32f10x_cl.c
  group Core Code
    ./: core_cm3.c
  group Source
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target MCBSTM32C + OPT (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: as above
  output: BlinkyOPT
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
